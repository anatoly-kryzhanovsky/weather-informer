#include "resource.h"

unsigned char Resources::IconSun[] = {
  0x80, 0x00, 0x80, 0x00,
  0x84, 0x10, 0xe8, 0x0b,
  0x30, 0x06, 0x10, 0x04,
  0x10, 0x04, 0x1f, 0x7c,
  0x10, 0x04, 0x10, 0x04,
  0x30, 0x06, 0xe8, 0x0b,
  0x84, 0x10, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x00 
};

unsigned char Resources::IconCloud[] = {
  0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0xc0, 0x00, 
  0x20, 0x03, 0x10, 0x02, 
  0x10, 0x3c, 0x1c, 0x60, 
  0x06, 0x40, 0x02, 0x40,
  0x02, 0x20, 0xfc, 0x1f, 
  0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00 
};

unsigned char Resources::IconRainLight[] = {
  0x00, 0x00, 0xc0, 0x00,
  0xe0, 0x03, 0xf0, 0x03,
  0xf0, 0x3f, 0xfc, 0x7f,
  0xfe, 0x7f, 0xfe, 0x7f,
  0xfe, 0x3f, 0xfc, 0x1f,
  0x40, 0x00, 0x20, 0x00,
  0x10, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x00, 0x00 
};

unsigned char Resources::IconRainHeavy[] = {
  0x00, 0x00, 0xc0, 0x00,
  0xe0, 0x03, 0xf0, 0x03,
  0xf0, 0x3f, 0xfc, 0x7f,
  0xfe, 0x7f, 0xfe, 0x7f,
  0xfe, 0x3f, 0xfc, 0x1f,
  0x88, 0x08, 0x54, 0x05,
  0xaa, 0x02, 0x44, 0x00,
  0x00, 0x00, 0x00, 0x00
};

unsigned char Resources::IconCloudLight[] = {
  0x80, 0x88, 0x00, 0x5d, 
  0x00, 0x22, 0xc0, 0x41, 
  0x20, 0xc3, 0x10, 0x42, 
  0x10, 0x3c, 0x0c, 0x60, 
  0x02, 0x40, 0x02, 0x40,
  0x06, 0x30, 0xfc, 0x1f, 
  0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00 
};

unsigned char Resources::IconSnowLight[] = {
  0x00, 0x00, 0xc0, 0x00,
  0x20, 0x03, 0x10, 0x02,
  0x10, 0x3c, 0x0c, 0x40,
  0x02, 0x40, 0x02, 0x40,
  0x02, 0x20, 0xfc, 0x1f,
  0x80, 0x00, 0xa0, 0x02,
  0xc0, 0x01, 0xc0, 0x01,
  0xa0, 0x02, 0x80, 0x00
};
  
unsigned char Resources::IconSnowHeavy[] = {
  0x00, 0x00, 0xc0, 0x00,
  0x20, 0x03, 0x10, 0x02,
  0x10, 0x3c, 0x0c, 0x40,
  0x02, 0x40, 0x02, 0x40,
  0x02, 0x20, 0xfc, 0x1f,
  0x84, 0x20, 0xb5, 0xaa,
  0xce, 0x71, 0xce, 0x71,
  0xb5, 0xaa, 0x84, 0x20
};
  
unsigned char Resources::IconRainAndSnow[] = {
  0x00, 0x00, 0xc0, 0x00,
  0x20, 0x03, 0x10, 0x02,
  0x10, 0x3c, 0x0c, 0x40,
  0x02, 0x40, 0x02, 0x40,
  0x02, 0x20, 0xfc, 0x1f,
  0x88, 0x40, 0xa4, 0x22,
  0xc2, 0x11, 0xc8, 0x81,
  0xa4, 0x42, 0x82, 0x20
};

unsigned char Resources::IconThunderstorm[] = {
  0x00, 0x00, 0xc0, 0x00,
  0x20, 0x03, 0x10, 0x02,
  0x10, 0x3c, 0x0c, 0x40,
  0x02, 0x4e, 0x02, 0x47,
  0x82, 0x23, 0xdc, 0x10,
  0xd0, 0x07, 0xc8, 0x0f,
  0x04, 0x0e, 0x10, 0x07,
  0x88, 0x03, 0xc4, 0x00
};

unsigned char Resources::IconUnknow[] = {
  0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xc0, 0x07,
  0x20, 0x08, 0x20, 0x08,
  0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x03,
  0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00
}

unsigned char* Resources::getIcon(int weatherCode)
{
    if(weatherCode == 800)
      return IconSun;

    if(weatherCode == 801)
      return IconCloudLight;

    if(weatherCode >= 802 && weatherCode <= 804)
      return IconCloud;

    if((weatherCode >= 500 && weatherCode <= 504) || 
      (weatherCode >=300 && weatherCode < 400))
      return IconRainLight;

    if(weatherCode >= 511 && weatherCode <= 531)
      return IconRainHeavy;

    if(weatherCode >= 600 && weatherCode <= 601)
      return IconSnowLight;

    if(weatherCode >= 602 && weatherCode <= 612)
      return IconSnowHeavy;

    if(weatherCode >= 200 && weatherCode < 300)
      return IconThunderstorm;

    if(weatherCode >= 615 && weatherCode <= 622)
      return IconRainAndSnow;

    return IconUnknow;
}